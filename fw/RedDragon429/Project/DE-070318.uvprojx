# Keil uVision project DE-070318.uvprojx, settings and files
target DE-070318 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DE-070318 +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output=DE-070318.bin F:\SkyDrive\OtvoreniProjekti\HotelHills\fw\HotelController\DE-070318\Project\Obj\DE-070318.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER, USE_LCD,
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\FreeRTOS\include;..\Libraries\lwip-1.4.1\src\include;..\Libraries\lwip-1.4.1\src\include\ipv4;..\Libraries\lwip-1.4.1\src\include\lwip;..\Libraries\lwip-1.4.1\src\include\netif;..\Libraries\lwip-1.4.1\port\arch;..\Libraries\lwip-1.4.1\port\Standalone;..\Libraries\lwip-1.4.1\src\netif;..\User\ETH_driver;..\Application;..\Driver;..\User\TFTP_Server;..\User\FATFS;..\User\Http;..\Utilities\STM32_EVAL\Common;..\Demo;..\Libraries\STemWinLibrary532\inc;..\Libraries\STemWinLibrary532\Config;..\Application\Dsiplay
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Libraries/CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries/StdPeriph_Driver_v1.5.0
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_fmc.c stm32f4xx_dma2d.c stm32f4xx_ltdc.c stm32f4xx_i2c.c stm32f4xx_adc.c stm32f4xx_rtc.c stm32f4xx_iwdg.c stm32f4xx_dcmi.c
  group Libraries/STemWinLibrary540
    ../Libraries/Config/: GUIConf.c GUIDRV_stm32f429i.c GUI_X.c GUI_X_Touch.c
    ../Libraries/STemWinLibrary532/Lib/: STemWin532_CM4_Keil.lib
  group Libraries/lwip-1.4.1
    ../Libraries/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Libraries/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../Libraries/lwip-1.4.1/src/netif/: etharp.c slipif.c
    ../Libraries/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Libraries/lwip-1.4.1/port/Standalone/: ethernetif.c
  group DEVICE_Driver
    ../Application/: rtc.c
    ../Driver/: delay.c Gpio.c stm32f429i_lcd.c stm32f429i_sdram.c W25Q16.c sdio_sd.c Uart.c buzzer.c i2c_eeprom.c RTP_Touch.c
  group TFTP_Server
    ../User/TFTP_Server/: sys_arch.c netconf.c fatfs_drv.c tftpserver.c tftputils.c
  group HTTP_Server
    ../User/Http/: fs.c httpd.c httpd_cgi_ssi.c
  group ETH_Driver
    ../User/ETH_driver/: stm32f4x7_eth.c eth_bsp.c
  group GUI_Display
    ../Application/Dsiplay/: Display.c NetworkConnected.c NetworkError.c usd_error.c usd_ok.c WB_LOGO.c
    ../Driver/: mt9d111.c ov2640.c ov5642.c ov7670.c sccb_bus.c
  group FATFS
    ../User/FATFS/: ff.c
  group Application
    ../Application/: main.c stm32f4xx_it.c hotel_room_controller.c common.c
