# Keil uVision project DE-010318.uvprojx, settings and files
target DE-010318 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DE-010318
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output=DE-010318.bin F:\SkyDrive\OtvoreniProjekti\HotelHills\fw\HotelController\DE-010318\Project\Obj\DE-010318.axf
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER, USE_LCD,
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\FreeRTOS\include;..\Libraries\lwip-1.4.1\src\include;..\Libraries\lwip-1.4.1\src\include\ipv4;..\Libraries\lwip-1.4.1\src\include\lwip;..\Libraries\lwip-1.4.1\src\include\netif;..\Libraries\lwip-1.4.1\port\arch;..\Libraries\lwip-1.4.1\port\Standalone;..\Libraries\lwip-1.4.1\src\netif;..\User\ETH_driver;..\Application;..\Driver;..\User\TFTP_Server;..\User\FATFS;..\User\Http;..\Utilities\STM32_EVAL\Common;..\Demo;..\Libraries\STemWinLibrary532\inc;..\Libraries\STemWinLibrary532\Config;..\Application\Dsiplay;..\Libraries\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Libraries/CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries/StdPeriph_Driver_v1.5.0
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_fmc.c stm32f4xx_dma2d.c stm32f4xx_ltdc.c stm32f4xx_i2c.c stm32f4xx_adc.c stm32f4xx_rtc.c
  group DEVICE_Driver
    ../Driver/: sdio_sd.c i2c_eeprom.c dio.c stm32f429i_lcd.c stm32f429i_sdram.c rtc.c
  group FATFS
    ../User/FATFS/: ff.c
    ../User/TFTP_Server/: fatfs_drv.c
    ../Driver/: flash_if.c
  group Application
    ../Application/: main.c stm32f4xx_it.c
    ../Driver/: command.c
